#pragma once
#include <ArduinoJson.h>
#include <math.h>
inline void policyDefaults(JsonDocument &d){
d["explorationBranchPercent"]=20;
d["touchFlashPercent"]=20;
d["touchPreyPercent"]=20;
d["touchSlowEscapePercent"]=40;
d["touchFastEscapePercent"]=40;
d["catFollowProbePercent"]=5;
d["catFollowObservePercent"]=35;
d["catFollowPatrolPercent"]=60;
d["endingAfterRounds"]=3;
d["endingInactivitySeconds"]=12;
d["endingPatrolPercent"]=40;
d["endingSilentPercent"]=30;
d["endingSignalPercent"]=30;
d["captureWaitMaxSeconds"]=15;
d["captureCueFlashMs"]=2200;
d["captureCueBeepMs"]=360;
d["robotFarApproachPercent"]=85;
d["robotFarProbePercent"]=15;
d["robotNearSignalPercent"]=20;
d["robotNearObservePercent"]=40;
d["robotNearStayPercent"]=40;
d["catProbeCooldownSeconds"]=15;
d["robotProbeCooldownSeconds"]=15;
d["farCatThresholdCm"]=40;
d["initialLookSeconds"]=5;
d["postEscapeWaitSeconds"]=10;
d["touchDebounceMs"]=1000;
d["catLeaveDistanceCm"]=70;
d["catLeaveSeconds"]=5;
d["sessionLimitSeconds"]=60;
d["decisionIntervalMs"]=2500;
d["searchTimeoutMs"]=15000;
d["finalSearchTimeoutMs"]=8000;
d["alignTimeoutMs"]=5000;
d["touchReleaseTimeoutMs"]=4000;
d["searchPwm"]=75;
d["centerTolerancePercent"]=5.5;
d["alignPwm"]=52;
d["slowApproachCm"]=9;
d["slowApproachPwm"]=95;
d["probeStep1Cm"]=3;
d["probeStep2Cm"]=4;
d["probeStep3Cm"]=3;
d["probePause1Ms"]=700;
d["probePause2Ms"]=900;
d["probePause3Ms"]=600;
d["probePwm"]=90;
d["signalFlashMs"]=1400;
d["signalBeepMs"]=180;
d["touchFeedbackBeepMs"]=180;
d["escapeDistanceCm"]=26;
d["slowEscapePwm"]=95;
d["fastEscapePwm"]=210;
d["tagLossGraceMs"]=1000;
d["tagRecoveryAngleDeg"]=60;
d["tagScanMaxFrames"]=3;
d["catCheckMaxFrames"]=3;
d["robotActionLimit"]=5;
d["robotFastApproachCm"]=15;
d["robotFastApproachPwm"]=180;
d["robotSlowFlashPercent"]=50;
d["tagCenterTolerancePercent"]=5.5;
d["catInteractionIdleSeconds"]=12;
d["catObserveTimeoutSeconds"]=10;
d["escapeMinDistanceCm"]=23;
d["escapeMaxDistanceCm"]=23;
d["escapeTurnClearanceCm"]=15;
d["catConfirmWaitSeconds"]=5;
d["catConfirmPreyPercent"]=20;
d["catConfirmExplorePercent"]=20;
d["escapePreyAfterRounds"]=5;
d["escapePreyPercent"]=20;
d["explorePreyMinimumSeconds"]=30;
d["explorePreyPercent"]=20;
d["minimumDrivePwm"]=140;
d["scanStepPulses"]=2;
d["scanMinimumMs"]=200;
d["scanQuietMs"]=100;
d["scanVisionTimeoutMs"]=3000;
d["scanSettleTimeoutMs"]=3000;
d["catSettleTimeoutMs"]=6000;
d["catApproachStepCm"]=1;
}
inline void migrateCenterSettings(JsonDocument &candidate,JsonDocument &saved){if(!saved["tagCenterTolerancePercent"].is<float>())candidate["tagCenterTolerancePercent"]=candidate["centerTolerancePercent"]; }
inline bool validateSettings(JsonDocument &d,String &error){
if(!d["explorationBranchPercent"].is<float>()||!isfinite(d["explorationBranchPercent"].as<float>())||d["explorationBranchPercent"].as<float>()<0||d["explorationBranchPercent"].as<float>()>100){error="invalid explorationBranchPercent";return false;}
if(!d["touchFlashPercent"].is<float>()||!isfinite(d["touchFlashPercent"].as<float>())||d["touchFlashPercent"].as<float>()<0||d["touchFlashPercent"].as<float>()>100){error="invalid touchFlashPercent";return false;}
if(!d["touchPreyPercent"].is<float>()||!isfinite(d["touchPreyPercent"].as<float>())||d["touchPreyPercent"].as<float>()<0||d["touchPreyPercent"].as<float>()>100){error="invalid touchPreyPercent";return false;}
if(!d["touchSlowEscapePercent"].is<float>()||!isfinite(d["touchSlowEscapePercent"].as<float>())||d["touchSlowEscapePercent"].as<float>()<0||d["touchSlowEscapePercent"].as<float>()>100){error="invalid touchSlowEscapePercent";return false;}
if(!d["touchFastEscapePercent"].is<float>()||!isfinite(d["touchFastEscapePercent"].as<float>())||d["touchFastEscapePercent"].as<float>()<0||d["touchFastEscapePercent"].as<float>()>100){error="invalid touchFastEscapePercent";return false;}
if(!d["catFollowProbePercent"].is<float>()||!isfinite(d["catFollowProbePercent"].as<float>())||d["catFollowProbePercent"].as<float>()<0||d["catFollowProbePercent"].as<float>()>100){error="invalid catFollowProbePercent";return false;}
if(!d["catFollowObservePercent"].is<float>()||!isfinite(d["catFollowObservePercent"].as<float>())||d["catFollowObservePercent"].as<float>()<0||d["catFollowObservePercent"].as<float>()>100){error="invalid catFollowObservePercent";return false;}
if(!d["catFollowPatrolPercent"].is<float>()||!isfinite(d["catFollowPatrolPercent"].as<float>())||d["catFollowPatrolPercent"].as<float>()<0||d["catFollowPatrolPercent"].as<float>()>100){error="invalid catFollowPatrolPercent";return false;}
if(!d["endingAfterRounds"].is<float>()||!isfinite(d["endingAfterRounds"].as<float>())||d["endingAfterRounds"].as<float>()<0||d["endingAfterRounds"].as<float>()>20){error="invalid endingAfterRounds";return false;}
if(!d["endingInactivitySeconds"].is<float>()||!isfinite(d["endingInactivitySeconds"].as<float>())||d["endingInactivitySeconds"].as<float>()<0||d["endingInactivitySeconds"].as<float>()>120){error="invalid endingInactivitySeconds";return false;}
if(!d["endingPatrolPercent"].is<float>()||!isfinite(d["endingPatrolPercent"].as<float>())||d["endingPatrolPercent"].as<float>()<0||d["endingPatrolPercent"].as<float>()>100){error="invalid endingPatrolPercent";return false;}
if(!d["endingSilentPercent"].is<float>()||!isfinite(d["endingSilentPercent"].as<float>())||d["endingSilentPercent"].as<float>()<0||d["endingSilentPercent"].as<float>()>100){error="invalid endingSilentPercent";return false;}
if(!d["endingSignalPercent"].is<float>()||!isfinite(d["endingSignalPercent"].as<float>())||d["endingSignalPercent"].as<float>()<0||d["endingSignalPercent"].as<float>()>100){error="invalid endingSignalPercent";return false;}
if(!d["captureWaitMaxSeconds"].is<float>()||!isfinite(d["captureWaitMaxSeconds"].as<float>())||d["captureWaitMaxSeconds"].as<float>()<1||d["captureWaitMaxSeconds"].as<float>()>60){error="invalid captureWaitMaxSeconds";return false;}
if(!d["captureCueFlashMs"].is<float>()||!isfinite(d["captureCueFlashMs"].as<float>())||d["captureCueFlashMs"].as<float>()<1000||d["captureCueFlashMs"].as<float>()>5000){error="invalid captureCueFlashMs";return false;}
if(!d["captureCueBeepMs"].is<float>()||!isfinite(d["captureCueBeepMs"].as<float>())||d["captureCueBeepMs"].as<float>()<100||d["captureCueBeepMs"].as<float>()>1000){error="invalid captureCueBeepMs";return false;}
if(!d["robotFarApproachPercent"].is<float>()||!isfinite(d["robotFarApproachPercent"].as<float>())||d["robotFarApproachPercent"].as<float>()<0||d["robotFarApproachPercent"].as<float>()>100){error="invalid robotFarApproachPercent";return false;}
if(!d["robotFarProbePercent"].is<float>()||!isfinite(d["robotFarProbePercent"].as<float>())||d["robotFarProbePercent"].as<float>()<0||d["robotFarProbePercent"].as<float>()>100){error="invalid robotFarProbePercent";return false;}
if(!d["robotNearSignalPercent"].is<float>()||!isfinite(d["robotNearSignalPercent"].as<float>())||d["robotNearSignalPercent"].as<float>()<0||d["robotNearSignalPercent"].as<float>()>100){error="invalid robotNearSignalPercent";return false;}
if(!d["robotNearObservePercent"].is<float>()||!isfinite(d["robotNearObservePercent"].as<float>())||d["robotNearObservePercent"].as<float>()<0||d["robotNearObservePercent"].as<float>()>100){error="invalid robotNearObservePercent";return false;}
if(!d["robotNearStayPercent"].is<float>()||!isfinite(d["robotNearStayPercent"].as<float>())||d["robotNearStayPercent"].as<float>()<0||d["robotNearStayPercent"].as<float>()>100){error="invalid robotNearStayPercent";return false;}
if(!d["catProbeCooldownSeconds"].is<float>()||!isfinite(d["catProbeCooldownSeconds"].as<float>())||d["catProbeCooldownSeconds"].as<float>()<0||d["catProbeCooldownSeconds"].as<float>()>60){error="invalid catProbeCooldownSeconds";return false;}
if(!d["robotProbeCooldownSeconds"].is<float>()||!isfinite(d["robotProbeCooldownSeconds"].as<float>())||d["robotProbeCooldownSeconds"].as<float>()<0||d["robotProbeCooldownSeconds"].as<float>()>60){error="invalid robotProbeCooldownSeconds";return false;}
if(!d["farCatThresholdCm"].is<float>()||!isfinite(d["farCatThresholdCm"].as<float>())||d["farCatThresholdCm"].as<float>()<20||d["farCatThresholdCm"].as<float>()>69){error="invalid farCatThresholdCm";return false;}
if(!d["initialLookSeconds"].is<float>()||!isfinite(d["initialLookSeconds"].as<float>())||d["initialLookSeconds"].as<float>()<0||d["initialLookSeconds"].as<float>()>30){error="invalid initialLookSeconds";return false;}
if(!d["postEscapeWaitSeconds"].is<float>()||!isfinite(d["postEscapeWaitSeconds"].as<float>())||d["postEscapeWaitSeconds"].as<float>()<0||d["postEscapeWaitSeconds"].as<float>()>60){error="invalid postEscapeWaitSeconds";return false;}
if(!d["touchDebounceMs"].is<float>()||!isfinite(d["touchDebounceMs"].as<float>())||d["touchDebounceMs"].as<float>()<0||d["touchDebounceMs"].as<float>()>5000){error="invalid touchDebounceMs";return false;}
if(!d["catLeaveDistanceCm"].is<float>()||!isfinite(d["catLeaveDistanceCm"].as<float>())||d["catLeaveDistanceCm"].as<float>()<41||d["catLeaveDistanceCm"].as<float>()>150){error="invalid catLeaveDistanceCm";return false;}
if(!d["catLeaveSeconds"].is<float>()||!isfinite(d["catLeaveSeconds"].as<float>())||d["catLeaveSeconds"].as<float>()<1||d["catLeaveSeconds"].as<float>()>30){error="invalid catLeaveSeconds";return false;}
if(!d["sessionLimitSeconds"].is<float>()||!isfinite(d["sessionLimitSeconds"].as<float>())||d["sessionLimitSeconds"].as<float>()<10||d["sessionLimitSeconds"].as<float>()>300){error="invalid sessionLimitSeconds";return false;}
if(!d["decisionIntervalMs"].is<float>()||!isfinite(d["decisionIntervalMs"].as<float>())||d["decisionIntervalMs"].as<float>()<0||d["decisionIntervalMs"].as<float>()>10000){error="invalid decisionIntervalMs";return false;}
if(!d["searchTimeoutMs"].is<float>()||!isfinite(d["searchTimeoutMs"].as<float>())||d["searchTimeoutMs"].as<float>()<1000||d["searchTimeoutMs"].as<float>()>30000){error="invalid searchTimeoutMs";return false;}
if(!d["finalSearchTimeoutMs"].is<float>()||!isfinite(d["finalSearchTimeoutMs"].as<float>())||d["finalSearchTimeoutMs"].as<float>()<1000||d["finalSearchTimeoutMs"].as<float>()>30000){error="invalid finalSearchTimeoutMs";return false;}
if(!d["alignTimeoutMs"].is<float>()||!isfinite(d["alignTimeoutMs"].as<float>())||d["alignTimeoutMs"].as<float>()<1000||d["alignTimeoutMs"].as<float>()>15000){error="invalid alignTimeoutMs";return false;}
if(!d["touchReleaseTimeoutMs"].is<float>()||!isfinite(d["touchReleaseTimeoutMs"].as<float>())||d["touchReleaseTimeoutMs"].as<float>()<500||d["touchReleaseTimeoutMs"].as<float>()>10000){error="invalid touchReleaseTimeoutMs";return false;}
if(!d["searchPwm"].is<float>()||!isfinite(d["searchPwm"].as<float>())||d["searchPwm"].as<float>()<30||d["searchPwm"].as<float>()>150){error="invalid searchPwm";return false;}
if(!d["centerTolerancePercent"].is<float>()||!isfinite(d["centerTolerancePercent"].as<float>())||d["centerTolerancePercent"].as<float>()<1||d["centerTolerancePercent"].as<float>()>20){error="invalid centerTolerancePercent";return false;}
if(!d["alignPwm"].is<float>()||!isfinite(d["alignPwm"].as<float>())||d["alignPwm"].as<float>()<30||d["alignPwm"].as<float>()>150){error="invalid alignPwm";return false;}
if(!d["slowApproachCm"].is<float>()||!isfinite(d["slowApproachCm"].as<float>())||d["slowApproachCm"].as<float>()<1||d["slowApproachCm"].as<float>()>30){error="invalid slowApproachCm";return false;}
if(!d["slowApproachPwm"].is<float>()||!isfinite(d["slowApproachPwm"].as<float>())||d["slowApproachPwm"].as<float>()<50||d["slowApproachPwm"].as<float>()>255){error="invalid slowApproachPwm";return false;}
if(!d["probeStep1Cm"].is<float>()||!isfinite(d["probeStep1Cm"].as<float>())||d["probeStep1Cm"].as<float>()<1||d["probeStep1Cm"].as<float>()>20){error="invalid probeStep1Cm";return false;}
if(!d["probeStep2Cm"].is<float>()||!isfinite(d["probeStep2Cm"].as<float>())||d["probeStep2Cm"].as<float>()<1||d["probeStep2Cm"].as<float>()>20){error="invalid probeStep2Cm";return false;}
if(!d["probeStep3Cm"].is<float>()||!isfinite(d["probeStep3Cm"].as<float>())||d["probeStep3Cm"].as<float>()<1||d["probeStep3Cm"].as<float>()>20){error="invalid probeStep3Cm";return false;}
if(!d["probePause1Ms"].is<float>()||!isfinite(d["probePause1Ms"].as<float>())||d["probePause1Ms"].as<float>()<0||d["probePause1Ms"].as<float>()>3000){error="invalid probePause1Ms";return false;}
if(!d["probePause2Ms"].is<float>()||!isfinite(d["probePause2Ms"].as<float>())||d["probePause2Ms"].as<float>()<0||d["probePause2Ms"].as<float>()>3000){error="invalid probePause2Ms";return false;}
if(!d["probePause3Ms"].is<float>()||!isfinite(d["probePause3Ms"].as<float>())||d["probePause3Ms"].as<float>()<0||d["probePause3Ms"].as<float>()>3000){error="invalid probePause3Ms";return false;}
if(!d["probePwm"].is<float>()||!isfinite(d["probePwm"].as<float>())||d["probePwm"].as<float>()<50||d["probePwm"].as<float>()>255){error="invalid probePwm";return false;}
if(!d["signalFlashMs"].is<float>()||!isfinite(d["signalFlashMs"].as<float>())||d["signalFlashMs"].as<float>()<100||d["signalFlashMs"].as<float>()>5000){error="invalid signalFlashMs";return false;}
if(!d["signalBeepMs"].is<float>()||!isfinite(d["signalBeepMs"].as<float>())||d["signalBeepMs"].as<float>()<0||d["signalBeepMs"].as<float>()>1000){error="invalid signalBeepMs";return false;}
if(!d["touchFeedbackBeepMs"].is<float>()||!isfinite(d["touchFeedbackBeepMs"].as<float>())||d["touchFeedbackBeepMs"].as<float>()<100||d["touchFeedbackBeepMs"].as<float>()>1000){error="invalid touchFeedbackBeepMs";return false;}
if(!d["escapeDistanceCm"].is<float>()||!isfinite(d["escapeDistanceCm"].as<float>())||d["escapeDistanceCm"].as<float>()<1||d["escapeDistanceCm"].as<float>()>60){error="invalid escapeDistanceCm";return false;}
if(!d["slowEscapePwm"].is<float>()||!isfinite(d["slowEscapePwm"].as<float>())||d["slowEscapePwm"].as<float>()<50||d["slowEscapePwm"].as<float>()>255){error="invalid slowEscapePwm";return false;}
if(!d["fastEscapePwm"].is<float>()||!isfinite(d["fastEscapePwm"].as<float>())||d["fastEscapePwm"].as<float>()<50||d["fastEscapePwm"].as<float>()>255){error="invalid fastEscapePwm";return false;}
if(!d["tagLossGraceMs"].is<float>()||!isfinite(d["tagLossGraceMs"].as<float>())||d["tagLossGraceMs"].as<float>()<0||d["tagLossGraceMs"].as<float>()>3000){error="invalid tagLossGraceMs";return false;}
if(!d["tagRecoveryAngleDeg"].is<float>()||!isfinite(d["tagRecoveryAngleDeg"].as<float>())||d["tagRecoveryAngleDeg"].as<float>()<20||d["tagRecoveryAngleDeg"].as<float>()>120){error="invalid tagRecoveryAngleDeg";return false;}
if(!d["tagScanMaxFrames"].is<float>()||!isfinite(d["tagScanMaxFrames"].as<float>())||d["tagScanMaxFrames"].as<float>()<1||d["tagScanMaxFrames"].as<float>()>10){error="invalid tagScanMaxFrames";return false;}
if(!d["catCheckMaxFrames"].is<float>()||!isfinite(d["catCheckMaxFrames"].as<float>())||d["catCheckMaxFrames"].as<float>()<1||d["catCheckMaxFrames"].as<float>()>3){error="invalid catCheckMaxFrames";return false;}
if(!d["robotActionLimit"].is<float>()||!isfinite(d["robotActionLimit"].as<float>())||d["robotActionLimit"].as<float>()<1||d["robotActionLimit"].as<float>()>100){error="invalid robotActionLimit";return false;}
if(!d["robotFastApproachCm"].is<float>()||!isfinite(d["robotFastApproachCm"].as<float>())||d["robotFastApproachCm"].as<float>()<1||d["robotFastApproachCm"].as<float>()>50){error="invalid robotFastApproachCm";return false;}
if(!d["robotFastApproachPwm"].is<float>()||!isfinite(d["robotFastApproachPwm"].as<float>())||d["robotFastApproachPwm"].as<float>()<50||d["robotFastApproachPwm"].as<float>()>255){error="invalid robotFastApproachPwm";return false;}
if(!d["robotSlowFlashPercent"].is<float>()||!isfinite(d["robotSlowFlashPercent"].as<float>())||d["robotSlowFlashPercent"].as<float>()<0||d["robotSlowFlashPercent"].as<float>()>100){error="invalid robotSlowFlashPercent";return false;}
if(!d["tagCenterTolerancePercent"].is<float>()||!isfinite(d["tagCenterTolerancePercent"].as<float>())||d["tagCenterTolerancePercent"].as<float>()<1||d["tagCenterTolerancePercent"].as<float>()>20){error="invalid tagCenterTolerancePercent";return false;}
if(!d["catInteractionIdleSeconds"].is<float>()||!isfinite(d["catInteractionIdleSeconds"].as<float>())||d["catInteractionIdleSeconds"].as<float>()<1||d["catInteractionIdleSeconds"].as<float>()>120){error="invalid catInteractionIdleSeconds";return false;}
if(!d["catObserveTimeoutSeconds"].is<float>()||!isfinite(d["catObserveTimeoutSeconds"].as<float>())||d["catObserveTimeoutSeconds"].as<float>()<1||d["catObserveTimeoutSeconds"].as<float>()>120){error="invalid catObserveTimeoutSeconds";return false;}
if(!d["escapeMinDistanceCm"].is<float>()||!isfinite(d["escapeMinDistanceCm"].as<float>())||d["escapeMinDistanceCm"].as<float>()<1||d["escapeMinDistanceCm"].as<float>()>100){error="invalid escapeMinDistanceCm";return false;}
if(!d["escapeMaxDistanceCm"].is<float>()||!isfinite(d["escapeMaxDistanceCm"].as<float>())||d["escapeMaxDistanceCm"].as<float>()<1||d["escapeMaxDistanceCm"].as<float>()>100){error="invalid escapeMaxDistanceCm";return false;}
if(!d["escapeTurnClearanceCm"].is<float>()||!isfinite(d["escapeTurnClearanceCm"].as<float>())||d["escapeTurnClearanceCm"].as<float>()<1||d["escapeTurnClearanceCm"].as<float>()>100){error="invalid escapeTurnClearanceCm";return false;}
if(!d["catConfirmWaitSeconds"].is<float>()||!isfinite(d["catConfirmWaitSeconds"].as<float>())||d["catConfirmWaitSeconds"].as<float>()<0||d["catConfirmWaitSeconds"].as<float>()>30){error="invalid catConfirmWaitSeconds";return false;}
if(!d["catConfirmPreyPercent"].is<float>()||!isfinite(d["catConfirmPreyPercent"].as<float>())||d["catConfirmPreyPercent"].as<float>()<0||d["catConfirmPreyPercent"].as<float>()>100){error="invalid catConfirmPreyPercent";return false;}
if(!d["catConfirmExplorePercent"].is<float>()||!isfinite(d["catConfirmExplorePercent"].as<float>())||d["catConfirmExplorePercent"].as<float>()<0||d["catConfirmExplorePercent"].as<float>()>100){error="invalid catConfirmExplorePercent";return false;}
if(!d["escapePreyAfterRounds"].is<float>()||!isfinite(d["escapePreyAfterRounds"].as<float>())||d["escapePreyAfterRounds"].as<float>()<1||d["escapePreyAfterRounds"].as<float>()>100){error="invalid escapePreyAfterRounds";return false;}
if(!d["escapePreyPercent"].is<float>()||!isfinite(d["escapePreyPercent"].as<float>())||d["escapePreyPercent"].as<float>()<0||d["escapePreyPercent"].as<float>()>100){error="invalid escapePreyPercent";return false;}
if(!d["explorePreyMinimumSeconds"].is<float>()||!isfinite(d["explorePreyMinimumSeconds"].as<float>())||d["explorePreyMinimumSeconds"].as<float>()<0||d["explorePreyMinimumSeconds"].as<float>()>600){error="invalid explorePreyMinimumSeconds";return false;}
if(!d["explorePreyPercent"].is<float>()||!isfinite(d["explorePreyPercent"].as<float>())||d["explorePreyPercent"].as<float>()<0||d["explorePreyPercent"].as<float>()>100){error="invalid explorePreyPercent";return false;}
if(!d["minimumDrivePwm"].is<float>()||!isfinite(d["minimumDrivePwm"].as<float>())||d["minimumDrivePwm"].as<float>()<1||d["minimumDrivePwm"].as<float>()>255){error="invalid minimumDrivePwm";return false;}
if(!d["scanStepPulses"].is<float>()||!isfinite(d["scanStepPulses"].as<float>())||d["scanStepPulses"].as<float>()<1||d["scanStepPulses"].as<float>()>64){error="invalid scanStepPulses";return false;}
if(!d["scanMinimumMs"].is<float>()||!isfinite(d["scanMinimumMs"].as<float>())||d["scanMinimumMs"].as<float>()<50||d["scanMinimumMs"].as<float>()>3000){error="invalid scanMinimumMs";return false;}
if(!d["scanQuietMs"].is<float>()||!isfinite(d["scanQuietMs"].as<float>())||d["scanQuietMs"].as<float>()<50||d["scanQuietMs"].as<float>()>3000){error="invalid scanQuietMs";return false;}
if(!d["scanVisionTimeoutMs"].is<float>()||!isfinite(d["scanVisionTimeoutMs"].as<float>())||d["scanVisionTimeoutMs"].as<float>()<500||d["scanVisionTimeoutMs"].as<float>()>10000){error="invalid scanVisionTimeoutMs";return false;}
if(!d["scanSettleTimeoutMs"].is<float>()||!isfinite(d["scanSettleTimeoutMs"].as<float>())||d["scanSettleTimeoutMs"].as<float>()<100||d["scanSettleTimeoutMs"].as<float>()>10000){error="invalid scanSettleTimeoutMs";return false;}
if(!d["catSettleTimeoutMs"].is<float>()||!isfinite(d["catSettleTimeoutMs"].as<float>())||d["catSettleTimeoutMs"].as<float>()<1000||d["catSettleTimeoutMs"].as<float>()>10000){error="invalid catSettleTimeoutMs";return false;}
if(!d["catApproachStepCm"].is<float>()||!isfinite(d["catApproachStepCm"].as<float>())||d["catApproachStepCm"].as<float>()<0.5||d["catApproachStepCm"].as<float>()>3){error="invalid catApproachStepCm";return false;}
if(!d["patrolSearchPwm"].is<float>()||!isfinite(d["patrolSearchPwm"].as<float>())||d["patrolSearchPwm"].as<float>()<30||d["patrolSearchPwm"].as<float>()>150){error="invalid patrolSearchPwm";return false;}
if(!d["patrolAlignPwm"].is<float>()||!isfinite(d["patrolAlignPwm"].as<float>())||d["patrolAlignPwm"].as<float>()<30||d["patrolAlignPwm"].as<float>()>150){error="invalid patrolAlignPwm";return false;}
if(!d["wheelMm"].is<float>()||!isfinite(d["wheelMm"].as<float>())||d["wheelMm"].as<float>()<20||d["wheelMm"].as<float>()>150){error="invalid wheelMm";return false;}
if(!d["trackMm"].is<float>()||!isfinite(d["trackMm"].as<float>())||d["trackMm"].as<float>()<50||d["trackMm"].as<float>()>300){error="invalid trackMm";return false;}
if(!d["stopMarginCm"].is<float>()||!isfinite(d["stopMarginCm"].as<float>())||d["stopMarginCm"].as<float>()<0||d["stopMarginCm"].as<float>()>15){error="invalid stopMarginCm";return false;}
if(!d["tagStopWidth"].is<float>()||!isfinite(d["tagStopWidth"].as<float>())||d["tagStopWidth"].as<float>()<0.02||d["tagStopWidth"].as<float>()>0.9){error="invalid tagStopWidth";return false;}
if(!d["catNearWidth"].is<float>()||!isfinite(d["catNearWidth"].as<float>())||d["catNearWidth"].as<float>()<0.02||d["catNearWidth"].as<float>()>0.9){error="invalid catNearWidth";return false;}
if(!d["catFarWidth"].is<float>()||!isfinite(d["catFarWidth"].as<float>())||d["catFarWidth"].as<float>()<0.01||d["catFarWidth"].as<float>()>0.8){error="invalid catFarWidth";return false;}
if(!d["visionMaxAgeMs"].is<float>()||!isfinite(d["visionMaxAgeMs"].as<float>())||d["visionMaxAgeMs"].as<float>()<100||d["visionMaxAgeMs"].as<float>()>5000){error="invalid visionMaxAgeMs";return false;}
if(!d["frontBlockBottom"].is<float>()||!isfinite(d["frontBlockBottom"].as<float>())||d["frontBlockBottom"].as<float>()<0.5||d["frontBlockBottom"].as<float>()>1){error="invalid frontBlockBottom";return false;}
if(!d["floorRoiTop"].is<float>()||!isfinite(d["floorRoiTop"].as<float>())||d["floorRoiTop"].as<float>()<0.5||d["floorRoiTop"].as<float>()>0.95){error="invalid floorRoiTop";return false;}
if(!d["floorDifferenceThreshold"].is<float>()||!isfinite(d["floorDifferenceThreshold"].as<float>())||d["floorDifferenceThreshold"].as<float>()<5||d["floorDifferenceThreshold"].as<float>()>100){error="invalid floorDifferenceThreshold";return false;}
if(d["escapeMinDistanceCm"].as<float>()>d["escapeMaxDistanceCm"].as<float>()){error="escape minimum exceeds maximum";return false;}
if(d["catConfirmPreyPercent"].as<float>()+d["catConfirmExplorePercent"].as<float>()>100){error="confirmed cat probabilities exceed 100";return false;}
for(auto route=d["route"].as<JsonArray>();JsonVariant id:route){if(!id.is<int>()||id.as<int>()<0||id.as<int>()>586){error="invalid tag ID";return false;}}
if(!d["route"].is<JsonArray>()||d["route"].size()>128){error="route size 0..128 (save a nonempty route before starting)";return false;}
if(d["catFarWidth"].as<float>()>=d["catNearWidth"].as<float>()){error="catFarWidth must be less than catNearWidth";return false;}
if(fabs(d["touchPreyPercent"].as<float>()+d["touchSlowEscapePercent"].as<float>()+d["touchFastEscapePercent"].as<float>()-100)>0.01){error="probability group must sum to 100: touchPreyPercent";return false;}
if(fabs(d["catFollowProbePercent"].as<float>()+d["catFollowObservePercent"].as<float>()+d["catFollowPatrolPercent"].as<float>()-100)>0.01){error="probability group must sum to 100: catFollowProbePercent";return false;}
if(fabs(d["endingPatrolPercent"].as<float>()+d["endingSilentPercent"].as<float>()+d["endingSignalPercent"].as<float>()-100)>0.01){error="probability group must sum to 100: endingPatrolPercent";return false;}
if(fabs(d["robotFarApproachPercent"].as<float>()+d["robotFarProbePercent"].as<float>()-100)>0.01){error="probability group must sum to 100: robotFarApproachPercent";return false;}
if(fabs(d["robotNearSignalPercent"].as<float>()+d["robotNearObservePercent"].as<float>()+d["robotNearStayPercent"].as<float>()-100)>0.01){error="probability group must sum to 100: robotNearSignalPercent";return false;}
if(!d["frontAvoidanceEnabled"].is<bool>()){error="invalid front avoidance flag";return false;}
if(!d["frontCalibrated"].is<bool>()){error="invalid calibration flag";return false;}
if(d["floorReference"].size()!=0&&d["floorReference"].size()!=72){error="invalid floor reference";return false;}
for(JsonVariant v:d["floorReference"].as<JsonArray>())if(!v.is<float>()||v.as<float>()<0||v.as<float>()>255){error="invalid floor reference";return false;}
if(d["scanSettleTimeoutMs"].as<float>()<=d["scanMinimumMs"].as<float>()||d["scanSettleTimeoutMs"].as<float>()<=d["scanQuietMs"].as<float>()){error="settle timeout must exceed both windows";return false;}
if(!d["scanStepPulses"].is<int>()){error="scan step pulses must be integer";return false;}
if(!d["minimumDrivePwm"].is<int>()){error="minimumDrivePwm must be integer";return false;}
for(const char *key:{"tagLossGraceMs","tagScanMaxFrames","catCheckMaxFrames","robotActionLimit","escapePreyAfterRounds","explorePreyMinimumSeconds"})if(!d[key].is<int>()){error="integer required";return false;}
return true;
}
